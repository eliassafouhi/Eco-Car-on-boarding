/*
 * ssd1306.c - minimal SSD1306 128x64 I2C OLED driver
 */
#include "ssd1306.h"
#include <string.h>

static I2C_HandleTypeDef *oled_i2c;
static uint8_t fb[SSD1306_WIDTH * SSD1306_HEIGHT / 8];
static uint8_t present;

/* Classic 5x7 font, ASCII 0x20..0x7E, 5 column bytes per glyph (LSB = top row) */
static const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62}, {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00}, {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
    {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00},
    {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14}, {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A},
    {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00}, {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F}, {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04}, {0x40,0x40,0x40,0x40,0x40},
    {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78}, {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7F}, {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x20,0x40,0x44,0x3D,0x00}, {0x7F,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78}, {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38},
    {0x7C,0x14,0x14,0x14,0x08}, {0x08,0x14,0x14,0x18,0x7C}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C}, {0x3C,0x40,0x30,0x40,0x3C},
    {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C}, {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x7F,0x00,0x00}, {0x00,0x41,0x36,0x08,0x00}, {0x10,0x08,0x08,0x10,0x08},
};

static HAL_StatusTypeDef cmd(uint8_t c)
{
    return HAL_I2C_Mem_Write(oled_i2c, SSD1306_ADDR, 0x00, I2C_MEMADD_SIZE_8BIT, &c, 1, 10);
}

HAL_StatusTypeDef SSD1306_Init(I2C_HandleTypeDef *hi2c)
{
    static const uint8_t init_seq[] = {
        0xAE,       /* display off */
        0xD5, 0x80, /* clock divide */
        0xA8, 0x3F, /* multiplex 64 */
        0xD3, 0x00, /* display offset */
        0x40,       /* start line 0 */
        0x8D, 0x14, /* charge pump on */
        0x20, 0x00, /* horizontal addressing */
        0xA1,       /* segment remap */
        0xC8,       /* COM scan descending */
        0xDA, 0x12, /* COM pins */
        0x81, 0xCF, /* contrast */
        0xD9, 0xF1, /* pre-charge */
        0xDB, 0x40, /* VCOMH */
        0xA4, 0xA6, /* resume RAM, normal (not inverted) */
        0xAF        /* display on */
    };
    oled_i2c = hi2c;
    present = 0;
    if (HAL_I2C_IsDeviceReady(hi2c, SSD1306_ADDR, 2, 20) != HAL_OK)
        return HAL_ERROR;           /* no OLED plugged in: board still works */
    for (unsigned i = 0; i < sizeof(init_seq); i++)
        if (cmd(init_seq[i]) != HAL_OK)
            return HAL_ERROR;
    present = 1;
    SSD1306_Clear();
    return SSD1306_Update();
}

uint8_t SSD1306_Present(void) { return present; }

void SSD1306_Clear(void) { memset(fb, 0, sizeof(fb)); }

void SSD1306_Pixel(int x, int y, uint8_t on)
{
    if (x < 0 || y < 0 || x >= SSD1306_WIDTH || y >= SSD1306_HEIGHT) return;
    if (on) fb[x + (y / 8) * SSD1306_WIDTH] |= (uint8_t)(1u << (y & 7));
    else    fb[x + (y / 8) * SSD1306_WIDTH] &= (uint8_t)~(1u << (y & 7));
}

void SSD1306_Rect(int x, int y, int w, int h, uint8_t fill)
{
    for (int i = 0; i < w; i++)
        for (int j = 0; j < h; j++)
            if (fill || i == 0 || j == 0 || i == w - 1 || j == h - 1)
                SSD1306_Pixel(x + i, y + j, 1);
}

void SSD1306_Text(int x, int y, const char *s, uint8_t scale)
{
    if (scale == 0) scale = 1;
    for (; *s; s++) {
        char c = *s;
        if (c < 0x20 || c > 0x7E) c = '?';
        const uint8_t *g = font5x7[c - 0x20];
        for (int col = 0; col < 5; col++)
            for (int row = 0; row < 7; row++)
                if (g[col] & (1u << row))
                    for (int a = 0; a < scale; a++)
                        for (int b = 0; b < scale; b++)
                            SSD1306_Pixel(x + col * scale + a, y + row * scale + b, 1);
        x += 6 * scale;
    }
}

HAL_StatusTypeDef SSD1306_Update(void)
{
    if (!present) return HAL_ERROR;
    cmd(0x21); cmd(0); cmd(127);   /* column range */
    cmd(0x22); cmd(0); cmd(7);     /* page range */
    for (unsigned i = 0; i < sizeof(fb); i += 64)
        if (HAL_I2C_Mem_Write(oled_i2c, SSD1306_ADDR, 0x40, I2C_MEMADD_SIZE_8BIT, &fb[i], 64, 50) != HAL_OK)
            return HAL_ERROR;
    return HAL_OK;
}
